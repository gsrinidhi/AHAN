# Keil uVision project OfflineCalibration.uvprojx, settings and files
target Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) IROM(0x00000000,0x7F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OfflineCalibration
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DEBUG, ADI_DEBUG, REDIRECT_OUTPUT_TO_UART, __ADUCM4050__
  c misc: --gnu
  c include: ..\..\..\bsp;..\..\..\..\adf703x;..\..\..\..\..\inc\devices\rf\adf703x;..\..\..\..\..\inc\devices\rf\adf703x\adf7030-1;..\..\..\..\..\inc\devices\rf\adf703x\config\Usecase_20;..\..\..\..\..\inc\devices\rf\adf703x\patch
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  group src
    ../../../: adf703x_OfflineCalibration.c adf703x_utils.c
  group bsp
    ../../../bsp/: common.c adi_initialize.c pinmux_config.c
  group rf_driver_src
    ../../../../../src/devices/rf/adf703x/: adf7030-1__cfg.c adf7030-1__core.c adf7030-1__gpio.c adf7030-1__irq.c adf7030-1__mem.c adf7030-1__patch.c adf7030-1__spi.c adf7030-1__state.c
software components: CMSIS:CORE 5.0.0, Device:Drivers:DMA 1.0.0, Device:Drivers:GPIO 1.0.0, Device:Drivers:Interrupt 1.0.0, Device:Drivers:Power 1.0.0, Device:Drivers:SPI 1.0.0, Device:Drivers:UART 1.0.0, Device:Drivers:WDT 1.0.0, Device:Global Configuration 1.0.0, Device:Retarget 1.0.0, Device:Startup 1.0.0
