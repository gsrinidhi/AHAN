# IAR project OfflineCalibration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM3029 AnalogDevices ADUCM3029
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __ADUCM3029__; ADI_DEBUG; REDIRECT_OUTPUT_TO_UART
  ICCARM.CCIncludePath2: .; ../.; $BSP_DIR$/inc; $BSP_DIR$/inc/config; ../../../../../inc/devices/rf/adf703x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OfflineCalibration.srec
  ILINK.IlinkOutputFile: OfflineCalibration.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ADUCM3029__; NDEBUG; REDIRECT_OUTPUT_TO_UART
  ICCARM.CCIncludePath2: .; ../.; ../../../../../examples/adf703x/bsp; ../../../../../inc/devices/rf/adf703x; $BSP_DIR$/inc; $BSP_DIR$/inc/config
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: $BSP_DIR$/inc; $BSP_DIR$/inc/config
  group Device
    ../../../../../src/devices/rf/adf703x/: adf7030-1__cfg.c adf7030-1__core.c adf7030-1__gpio.c adf7030-1__irq.c adf7030-1__mem.c adf7030-1__patch.c adf7030-1__spi.c adf7030-1__state.c
  group Source
    ../../../: adf703x_OfflineCalibration.c adf703x_utils.c
  group System
    $BSP_DIR$/src/services/dma/: adi_dma.c
    $BSP_DIR$/src/services/gpio/: adi_gpio.c
    $BSP_DIR$/src/services/pwr/: adi_pwr.c
    $BSP_DIR$/src/drivers/spi/: adi_spi.c
    $BSP_DIR$/src/services/tmr/: adi_tmr.c
    $BSP_DIR$/src/drivers/uart/: adi_uart.c
    $BSP_DIR$/src/services/wdt/: adi_wdt.c
    ../../../../adf703x/bsp/: common.c
    ../../: PinMux.c
    $BSP_DIR$/src/: startup.c system.c
