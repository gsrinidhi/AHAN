# IAR project OfflineCalibration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __ADUCM4050__; ADI_DEBUG; REDIRECT_OUTPUT_TO_UART
  ICCARM.CCIncludePath2: .; ../.; ../../../../../examples/adf703x/bsp; ../../../../../inc/devices/rf/adf703x; $BSP_DIR$/Include; $BSP_DIR$/Include/config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $BSP_DIR$/Include; $BSP_DIR$/Include/config
  OBJCOPY.OOCOutputFile: OfflineCalibration.srec
  ILINK.IlinkOutputFile: OfflineCalibration.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; REDIRECT_OUTPUT_TO_UART
  ICCARM.CCIncludePath2: .; ../.; $BSP_DIR$/Include; $BSP_DIR$/Include/config
  ICCARM.CCOptLevel: 3
  group Device
    ../../../../../src/devices/rf/adf703x/: adf7030-1__cfg.c adf7030-1__core.c adf7030-1__gpio.c adf7030-1__irq.c adf7030-1__mem.c adf7030-1__patch.c adf7030-1__spi.c adf7030-1__state.c
  group Source
    ../../../: adf703x_OfflineCalibration.c adf703x_utils.c
  group System
    $BSP_DIR$/Source/drivers/dma/: adi_dma.c
    $BSP_DIR$/Source/drivers/gpio/: adi_gpio.c
    $BSP_DIR$/Source/drivers/pwr/: adi_pwr.c
    $BSP_DIR$/Source/drivers/spi/: adi_spi.c
    ../: adi_spi_config.h
    $BSP_DIR$/Source/drivers/tmr/: adi_tmr.c
    $BSP_DIR$/Source/drivers/uart/: adi_uart.c
    $BSP_DIR$/Source/drivers/wdt/: adi_wdt.c
    ../../../bsp/: common.c pinmux_config.c
    $BSP_DIR$/Source/IAR/: startup_ADuCM4050.s
    $BSP_DIR$/Source/: system_ADuCM4050.c
